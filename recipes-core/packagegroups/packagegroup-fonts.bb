DESCRIPTION = "Web Platform for Embedded Framework Packagegroup"
LICENSE = "MIT"

inherit packagegroup

PACKAGES = "\
    packagegroup-fonts \
"

RDEPENDS_packagegroup-fonts = "\
    source-han-sans-cn-fonts \
    source-han-sans-jp-fonts \
    source-han-sans-kr-fonts \
    source-han-sans-tw-fonts \
    ttf-lohit \
"
